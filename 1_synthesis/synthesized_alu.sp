* SPICE netlist generated by Yosys 0.48 (git sha1 aaa534749, clang++ 18.1.3 -fPIC -O3)

X0 a.7 _abc_1393_new_n33 INV_X1
X1 a.6 _abc_1393_new_n34 INV_X1
X2 b.6 _abc_1393_new_n35 INV_X1
X3 a.5 _abc_1393_new_n36 INV_X1
X4 b.4 _abc_1393_new_n37 INV_X1
X5 a.3 _abc_1393_new_n38 INV_X1
X6 a.2 _abc_1393_new_n39 INV_X1
X7 b.2 _abc_1393_new_n40 INV_X1
X8 a.1 _abc_1393_new_n41 INV_X1
X9 b.1 _abc_1393_new_n42 INV_X1
X10 a.0 _abc_1393_new_n43 INV_X1
X11 b.0 _abc_1393_new_n44 INV_X1
X12 opcode.0 _abc_1393_new_n45 INV_X1
X13 opcode.1 _abc_1393_new_n46 INV_X1
X14 opcode.2 _abc_1393_new_n47 INV_X1
X15 rst_n _abc_1393_new_n48 INV_X1
X16 _abc_1393_auto_hilomap.cc:47:hilomap_worker_1391 rst_n _abc_1393_new_n49 NOR2_X1
X17 _abc_1393_new_n49 _abc_1393_new_n50 INV_X1
X18 opcode.3 _abc_1393_new_n47 _abc_1393_new_n51 NOR2_X1
X19 opcode.0 opcode.1 _abc_1393_new_n52 _abc_1393_new_n51 NAND3_X1
X20 a.6 b.6 _abc_1393_new_n53 NAND2_X1
X21 _abc_1393_new_n53 _abc_1393_new_n54 INV_X1
X22 a.6 b.6 _abc_1393_new_n55 XOR2_X1
X23 a.6 b.6 _abc_1393_new_n56 XNOR2_X1
X24 a.7 b.7 _abc_1393_new_n57 NAND2_X1
X25 _abc_1393_new_n57 _abc_1393_new_n58 INV_X1
X26 a.7 b.7 _abc_1393_new_n59 XOR2_X1
X27 _abc_1393_new_n36 b.5 _abc_1393_new_n60 NOR2_X1
X28 _abc_1393_new_n55 _abc_1393_new_n59 _abc_1393_new_n61 _abc_1393_new_n60 NOR3_X1
X29 _abc_1393_new_n36 b.5 _abc_1393_new_n62 NAND2_X1
X30 a.4 b.4 _abc_1393_new_n63 NAND2_X1
X31 _abc_1393_new_n63 _abc_1393_new_n64 INV_X1
X32 a.4 b.4 _abc_1393_new_n65 XOR2_X1
X33 a.4 b.4 _abc_1393_new_n66 XNOR2_X1
X34 a.4 _abc_1393_new_n37 _abc_1393_new_n67 NAND2_X1
X35 _abc_1393_new_n62 _abc_1393_new_n68 _abc_1393_new_n37 a.4 OAI21_X1
X36 _abc_1393_new_n61 _abc_1393_new_n62 _abc_1393_new_n69 _abc_1393_new_n66 NAND3_X1
X37 a.3 b.3 _abc_1393_new_n70 NAND2_X1
X38 a.3 b.3 _abc_1393_new_n71 XOR2_X1
X39 a.2 b.2 _abc_1393_new_n72 NOR2_X1
X40 a.2 b.2 _abc_1393_new_n73 AND2_X1
X41 _abc_1393_new_n72 _abc_1393_new_n73 _abc_1393_new_n74 NOR2_X1
X42 _abc_1393_new_n69 _abc_1393_new_n71 _abc_1393_new_n75 _abc_1393_new_n74 NOR3_X1
X43 a.0 _abc_1393_new_n44 _abc_1393_new_n76 NAND2_X1
X44 b.1 _abc_1393_new_n76 _abc_1393_new_n77 NAND2_X1
X45 b.1 _abc_1393_new_n76 _abc_1393_new_n78 NOR2_X1
X46 _abc_1393_new_n41 b.1 _abc_1393_new_n79 NOR2_X1
X47 _abc_1393_new_n77 _abc_1393_new_n80 _abc_1393_new_n78 a.1 OAI21_X1
X48 _abc_1393_new_n38 b.3 _abc_1393_new_n81 NOR2_X1
X49 a.2 _abc_1393_new_n40 _abc_1393_new_n82 _abc_1393_new_n81 NOR3_X1
X50 _abc_1393_new_n82 _abc_1393_new_n83 b.3 _abc_1393_new_n38 AOI21_X1
X51 a.6 _abc_1393_new_n35 _abc_1393_new_n84 _abc_1393_new_n59 NOR3_X1
X52 _abc_1393_new_n33 b.7 _abc_1393_new_n85 _abc_1393_new_n61 _abc_1393_new_n68 AOI22_X1
X53 _abc_1393_new_n85 _abc_1393_new_n86 _abc_1393_new_n83 _abc_1393_new_n69 OAI21_X1
X54 _abc_1393_new_n84 _abc_1393_new_n86 _abc_1393_new_n87 _abc_1393_new_n75 _abc_1393_new_n80 AOI211_X1
X55 opcode.0 opcode.1 _abc_1393_new_n88 _abc_1393_new_n51 _abc_1393_new_n87 AND4_X1
X56 opcode.0 _abc_1393_new_n46 _abc_1393_new_n89 _abc_1393_new_n51 NAND3_X1
X57 b.2 _abc_1393_new_n89 _abc_1393_new_n90 NOR2_X1
X58 _abc_1393_new_n45 opcode.1 _abc_1393_new_n91 _abc_1393_new_n51 NAND3_X1
X59 b.2 _abc_1393_new_n91 _abc_1393_new_n92 NOR2_X1
X60 _abc_1393_new_n40 _abc_1393_new_n91 _abc_1393_new_n93 NOR2_X1
X61 a.4 a.5 b.0 _abc_1393_new_n94 MUX2_X1
X62 _abc_1393_new_n42 _abc_1393_new_n94 _abc_1393_new_n95 NAND2_X1
X63 _abc_1393_new_n34 b.0 _abc_1393_new_n96 NOR2_X1
X64 _abc_1393_new_n96 _abc_1393_new_n97 b.0 a.7 AOI21_X1
X65 _abc_1393_new_n95 _abc_1393_new_n98 _abc_1393_new_n97 _abc_1393_new_n42 OAI21_X1
X66 a.0 b.0 _abc_1393_new_n99 NAND2_X1
X67 opcode.3 opcode.2 _abc_1393_new_n100 NOR2_X1
X68 opcode.1 _abc_1393_new_n100 _abc_1393_new_n101 NAND2_X1
X69 opcode.0 _abc_1393_new_n102 b.0 a.0 OAI21_X1
X70 _abc_1393_new_n101 _abc_1393_new_n103 _abc_1393_new_n102 _abc_1393_new_n99 AOI21_X1
X71 opcode.1 opcode.3 _abc_1393_new_n104 opcode.2 NOR3_X1
X72 opcode.0 opcode.1 _abc_1393_new_n105 opcode.3 _abc_1393_new_n47 NOR4_X1
X73 a.0 b.0 _abc_1393_new_n106 XOR2_X1
X74 _abc_1393_new_n106 _abc_1393_new_n107 _abc_1393_new_n105 _abc_1393_new_n104 OAI21_X1
X75 a.2 a.3 b.0 _abc_1393_new_n108 MUX2_X1
X76 a.1 b.0 _abc_1393_new_n109 NAND2_X1
X77 _abc_1393_new_n76 _abc_1393_new_n109 _abc_1393_new_n110 NAND2_X1
X78 _abc_1393_new_n108 _abc_1393_new_n110 _abc_1393_new_n42 _abc_1393_new_n111 MUX2_X1
X79 _abc_1393_new_n103 _abc_1393_new_n112 _abc_1393_new_n111 _abc_1393_new_n92 _abc_1393_new_n93 _abc_1393_new_n98 AOI221_X1
X80 _abc_1393_new_n107 _abc_1393_new_n112 _abc_1393_new_n113 NAND2_X1
X81 _abc_1393_new_n88 _abc_1393_new_n113 _abc_1393_new_n114 _abc_1393_new_n90 _abc_1393_new_n78 AOI211_X1
X82 _abc_1393_auto_hilomap.cc:47:hilomap_worker_1391 _abc_1393_new_n48 _abc_1393_new_n115 NAND2_X1
X83 _abc_1393_new_n49 _abc_1393_auto_rtlil.cc:2985:MuxGate_1362 _abc_1393_new_n114 rst_n AOI21_X1
X84 a.1 b.1 _abc_1393_new_n117 NAND2_X1
X85 a.1 b.1 _abc_1393_new_n118 XOR2_X1
X86 a.1 b.1 _abc_1393_new_n119 XNOR2_X1
X87 _abc_1393_new_n118 _abc_1393_new_n120 b.0 _abc_1393_new_n43 AOI21_X1
X88 _abc_1393_new_n119 _abc_1393_new_n121 _abc_1393_new_n44 a.0 OAI21_X1
X89 _abc_1393_new_n76 _abc_1393_new_n120 _abc_1393_new_n122 AND2_X1
X90 _abc_1393_new_n87 _abc_1393_new_n123 _abc_1393_new_n122 _abc_1393_new_n75 AOI21_X1
X91 _abc_1393_new_n52 _abc_1393_new_n87 _abc_1393_new_n124 _abc_1393_new_n122 _abc_1393_new_n75 AOI211_X1
X92 opcode.0 _abc_1393_new_n125 b.1 a.1 OAI21_X1
X93 _abc_1393_new_n101 _abc_1393_new_n126 _abc_1393_new_n117 _abc_1393_new_n125 AOI21_X1
X94 _abc_1393_new_n36 b.0 _abc_1393_new_n127 NOR2_X1
X95 _abc_1393_new_n127 _abc_1393_new_n128 b.0 a.6 AOI21_X1
X96 a.7 _abc_1393_new_n44 _abc_1393_new_n129 NAND2_X1
X97 a.7 b.1 _abc_1393_new_n130 _abc_1393_new_n44 NAND3_X1
X98 _abc_1393_new_n130 _abc_1393_new_n131 _abc_1393_new_n128 b.1 OAI21_X1
X99 _abc_1393_new_n126 _abc_1393_new_n132 _abc_1393_new_n131 _abc_1393_new_n93 _abc_1393_new_n105 _abc_1393_new_n118 AOI221_X1
X100 _abc_1393_new_n41 b.0 _abc_1393_new_n133 NOR2_X1
X101 _abc_1393_new_n133 _abc_1393_new_n134 b.0 a.0 AOI21_X1
X102 b.1 _abc_1393_new_n134 _abc_1393_new_n135 OR2_X1
X103 b.2 _abc_1393_new_n89 _abc_1393_new_n136 _abc_1393_new_n135 NOR3_X1
X104 _abc_1393_new_n38 b.0 _abc_1393_new_n137 NOR2_X1
X105 _abc_1393_new_n137 _abc_1393_new_n138 b.0 a.4 AOI21_X1
X106 b.1 _abc_1393_new_n133 _abc_1393_new_n139 b.0 a.2 AOI211_X1
X107 _abc_1393_new_n139 _abc_1393_new_n140 _abc_1393_new_n138 b.1 AOI21_X1
X108 _abc_1393_new_n136 _abc_1393_new_n141 _abc_1393_new_n140 _abc_1393_new_n92 AOI21_X1
X109 _abc_1393_new_n43 b.0 _abc_1393_new_n142 _abc_1393_new_n118 NAND3_X1
X110 opcode.0 _abc_1393_new_n104 _abc_1393_new_n143 AND2_X1
X111 opcode.0 _abc_1393_new_n104 _abc_1393_new_n144 NAND2_X1
X112 _abc_1393_new_n121 _abc_1393_new_n142 _abc_1393_new_n145 _abc_1393_new_n143 NAND3_X1
X113 _abc_1393_new_n45 _abc_1393_new_n104 _abc_1393_new_n146 NAND2_X1
X114 _abc_1393_new_n146 _abc_1393_new_n147 _abc_1393_new_n119 _abc_1393_new_n99 AOI21_X1
X115 _abc_1393_new_n147 _abc_1393_new_n148 _abc_1393_new_n119 _abc_1393_new_n99 OAI21_X1
X116 _abc_1393_new_n132 _abc_1393_new_n141 _abc_1393_new_n149 _abc_1393_new_n145 _abc_1393_new_n148 NAND4_X1
X117 _abc_1393_new_n124 _abc_1393_new_n149 _abc_1393_new_n150 NOR2_X1
X118 _abc_1393_new_n49 _abc_1393_auto_rtlil.cc:2985:MuxGate_1364 _abc_1393_new_n150 rst_n AOI21_X1
X119 _abc_1393_new_n117 _abc_1393_new_n152 _abc_1393_new_n119 _abc_1393_new_n99 OAI21_X1
X120 _abc_1393_new_n74 _abc_1393_new_n152 _abc_1393_new_n153 OR2_X1
X121 _abc_1393_new_n74 _abc_1393_new_n152 _abc_1393_new_n154 AND2_X1
X122 _abc_1393_new_n74 _abc_1393_new_n105 _abc_1393_new_n155 NAND2_X1
X123 _abc_1393_new_n155 _abc_1393_new_n156 _abc_1393_new_n154 _abc_1393_new_n146 OAI21_X1
X124 _abc_1393_new_n74 _abc_1393_new_n121 _abc_1393_new_n157 _abc_1393_new_n41 b.1 OAI211_X1
X125 _abc_1393_new_n72 _abc_1393_new_n73 _abc_1393_new_n158 _abc_1393_new_n79 _abc_1393_new_n120 OAI22_X1
X126 _abc_1393_new_n157 _abc_1393_new_n158 _abc_1393_new_n159 NAND2_X1
X127 _abc_1393_new_n94 _abc_1393_new_n108 _abc_1393_new_n42 _abc_1393_new_n160 MUX2_X1
X128 b.1 _abc_1393_new_n97 _abc_1393_new_n161 NOR2_X1
X129 _abc_1393_new_n92 _abc_1393_new_n160 _abc_1393_new_n162 _abc_1393_new_n161 _abc_1393_new_n93 AOI22_X1
X130 _abc_1393_new_n109 _abc_1393_new_n163 b.0 _abc_1393_new_n39 OAI21_X1
X131 _abc_1393_new_n163 _abc_1393_new_n164 INV_X1
X132 b.1 _abc_1393_new_n163 _abc_1393_new_n165 NOR2_X1
X133 _abc_1393_new_n165 _abc_1393_new_n166 _abc_1393_new_n76 b.1 AOI21_X1
X134 opcode.1 _abc_1393_new_n100 _abc_1393_new_n167 _abc_1393_new_n73 opcode.0 OAI211_X1
X135 _abc_1393_new_n167 _abc_1393_new_n168 _abc_1393_new_n72 opcode.0 AOI21_X1
X136 _abc_1393_new_n48 _abc_1393_new_n168 _abc_1393_new_n169 _abc_1393_new_n166 _abc_1393_new_n90 AOI211_X1
X137 _abc_1393_new_n162 _abc_1393_new_n169 _abc_1393_new_n170 _abc_1393_new_n144 _abc_1393_new_n159 OAI211_X1
X138 _abc_1393_new_n170 _abc_1393_new_n171 _abc_1393_new_n156 _abc_1393_new_n153 AOI21_X1
X139 _abc_1393_new_n49 _abc_1393_new_n171 _abc_1393_auto_rtlil.cc:2985:MuxGate_1366 NOR2_X1
X140 _abc_1393_new_n71 _abc_1393_new_n173 _abc_1393_new_n73 _abc_1393_new_n154 OAI21_X1
X141 _abc_1393_new_n71 _abc_1393_new_n73 _abc_1393_new_n174 _abc_1393_new_n154 NOR3_X1
X142 _abc_1393_new_n146 _abc_1393_new_n174 _abc_1393_new_n175 NOR2_X1
X143 a.2 _abc_1393_new_n40 _abc_1393_new_n176 NAND2_X1
X144 _abc_1393_new_n71 _abc_1393_new_n158 _abc_1393_new_n177 _abc_1393_new_n176 NAND3_X1
X145 _abc_1393_new_n71 _abc_1393_new_n178 _abc_1393_new_n158 _abc_1393_new_n176 AOI21_X1
X146 _abc_1393_new_n143 _abc_1393_new_n177 _abc_1393_new_n179 NAND2_X1
X147 a.3 a.2 b.0 _abc_1393_new_n180 MUX2_X1
X148 _abc_1393_new_n42 _abc_1393_new_n180 _abc_1393_new_n181 NAND2_X1
X149 _abc_1393_new_n181 _abc_1393_new_n182 _abc_1393_new_n134 _abc_1393_new_n42 OAI21_X1
X150 _abc_1393_new_n42 _abc_1393_new_n138 _abc_1393_new_n183 AND2_X1
X151 _abc_1393_new_n183 _abc_1393_new_n184 _abc_1393_new_n128 b.1 AOI21_X1
X152 _abc_1393_new_n90 _abc_1393_new_n182 _abc_1393_new_n185 _abc_1393_new_n184 _abc_1393_new_n92 AOI22_X1
X153 b.1 _abc_1393_new_n129 _abc_1393_new_n186 NOR2_X1
X154 opcode.0 _abc_1393_new_n187 b.3 a.3 OAI21_X1
X155 _abc_1393_new_n101 _abc_1393_new_n188 _abc_1393_new_n187 _abc_1393_new_n70 AOI21_X1
X156 _abc_1393_new_n188 _abc_1393_new_n189 _abc_1393_new_n186 _abc_1393_new_n93 _abc_1393_new_n71 _abc_1393_new_n105 AOI221_X1
X157 _abc_1393_new_n185 _abc_1393_new_n189 _abc_1393_new_n190 _abc_1393_new_n178 _abc_1393_new_n179 OAI211_X1
X158 _abc_1393_new_n190 _abc_1393_new_n191 _abc_1393_new_n175 _abc_1393_new_n173 AOI21_X1
X159 _abc_1393_new_n49 _abc_1393_auto_rtlil.cc:2985:MuxGate_1368 _abc_1393_new_n191 rst_n AOI21_X1
X160 _abc_1393_new_n66 _abc_1393_new_n193 _abc_1393_new_n81 _abc_1393_new_n178 OAI21_X1
X161 _abc_1393_new_n66 _abc_1393_new_n81 _abc_1393_new_n194 _abc_1393_new_n178 OR3_X1
X162 _abc_1393_new_n143 _abc_1393_new_n193 _abc_1393_new_n195 _abc_1393_new_n194 NAND3_X1
X163 _abc_1393_new_n66 _abc_1393_new_n196 _abc_1393_new_n70 _abc_1393_new_n173 AOI21_X1
X164 _abc_1393_new_n66 _abc_1393_new_n70 _abc_1393_new_n197 _abc_1393_new_n173 NAND3_X1
X165 _abc_1393_new_n146 _abc_1393_new_n196 _abc_1393_new_n198 NOR2_X1
X166 a.4 a.3 b.0 _abc_1393_new_n199 MUX2_X1
X167 _abc_1393_new_n40 _abc_1393_new_n200 b.1 _abc_1393_new_n199 OAI21_X1
X168 _abc_1393_new_n200 _abc_1393_new_n201 _abc_1393_new_n164 b.1 AOI21_X1
X169 _abc_1393_new_n201 _abc_1393_new_n202 _abc_1393_new_n78 b.2 AOI21_X1
X170 opcode.0 _abc_1393_new_n203 b.4 a.4 OAI21_X1
X171 _abc_1393_new_n101 _abc_1393_new_n204 _abc_1393_new_n203 _abc_1393_new_n63 AOI21_X1
X172 _abc_1393_new_n204 _abc_1393_new_n205 _abc_1393_new_n98 _abc_1393_new_n92 _abc_1393_new_n65 _abc_1393_new_n105 AOI221_X1
X173 _abc_1393_new_n195 _abc_1393_new_n205 _abc_1393_new_n206 _abc_1393_new_n202 _abc_1393_new_n89 OAI211_X1
X174 _abc_1393_new_n206 _abc_1393_new_n207 _abc_1393_new_n198 _abc_1393_new_n197 AOI21_X1
X175 _abc_1393_new_n49 _abc_1393_auto_rtlil.cc:2985:MuxGate_1370 _abc_1393_new_n207 rst_n AOI21_X1
X176 a.5 b.5 _abc_1393_new_n209 NAND2_X1
X177 a.5 b.5 _abc_1393_new_n210 XOR2_X1
X178 _abc_1393_new_n67 _abc_1393_new_n193 _abc_1393_new_n211 NAND2_X1
X179 _abc_1393_new_n210 _abc_1393_new_n211 _abc_1393_new_n212 XOR2_X1
X180 _abc_1393_new_n210 _abc_1393_new_n213 _abc_1393_new_n196 _abc_1393_new_n64 OAI21_X1
X181 _abc_1393_new_n64 _abc_1393_new_n196 _abc_1393_new_n214 _abc_1393_new_n210 NOR3_X1
X182 _abc_1393_new_n146 _abc_1393_new_n214 _abc_1393_new_n215 NOR2_X1
X183 b.1 _abc_1393_new_n180 _abc_1393_new_n216 NAND2_X1
X184 _abc_1393_new_n127 _abc_1393_new_n217 b.0 a.4 AOI21_X1
X185 _abc_1393_new_n216 _abc_1393_new_n218 _abc_1393_new_n217 b.1 OAI21_X1
X186 _abc_1393_new_n89 _abc_1393_new_n219 _abc_1393_new_n135 b.2 AOI21_X1
X187 _abc_1393_new_n219 _abc_1393_new_n220 _abc_1393_new_n218 b.2 OAI21_X1
X188 opcode.0 _abc_1393_new_n221 b.5 a.5 OAI21_X1
X189 _abc_1393_new_n101 _abc_1393_new_n222 _abc_1393_new_n209 _abc_1393_new_n221 AOI21_X1
X190 _abc_1393_new_n222 _abc_1393_new_n223 _abc_1393_new_n210 _abc_1393_new_n105 _abc_1393_new_n92 _abc_1393_new_n131 AOI221_X1
X191 _abc_1393_new_n220 _abc_1393_new_n223 _abc_1393_new_n224 _abc_1393_new_n144 _abc_1393_new_n212 OAI211_X1
X192 _abc_1393_new_n224 _abc_1393_new_n225 _abc_1393_new_n215 _abc_1393_new_n213 AOI21_X1
X193 _abc_1393_new_n49 _abc_1393_auto_rtlil.cc:2985:MuxGate_1372 _abc_1393_new_n225 rst_n AOI21_X1
X194 _abc_1393_new_n36 b.5 _abc_1393_new_n227 _abc_1393_new_n67 _abc_1393_new_n193 AOI22_X1
X195 _abc_1393_new_n56 _abc_1393_new_n228 _abc_1393_new_n60 _abc_1393_new_n227 OAI21_X1
X196 _abc_1393_new_n56 _abc_1393_new_n60 _abc_1393_new_n229 _abc_1393_new_n227 OR3_X1
X197 _abc_1393_new_n143 _abc_1393_new_n228 _abc_1393_new_n230 _abc_1393_new_n229 AND3_X1
X198 _abc_1393_new_n56 _abc_1393_new_n231 _abc_1393_new_n209 _abc_1393_new_n213 AOI21_X1
X199 _abc_1393_new_n56 _abc_1393_new_n209 _abc_1393_new_n232 _abc_1393_new_n213 NAND3_X1
X200 _abc_1393_new_n146 _abc_1393_new_n231 _abc_1393_new_n233 NOR2_X1
X201 opcode.0 _abc_1393_new_n234 b.6 a.6 OAI21_X1
X202 _abc_1393_new_n101 _abc_1393_new_n235 _abc_1393_new_n234 _abc_1393_new_n53 AOI21_X1
X203 _abc_1393_new_n42 _abc_1393_new_n236 _abc_1393_new_n44 _abc_1393_new_n36 OAI21_X1
X204 _abc_1393_new_n92 _abc_1393_new_n161 _abc_1393_new_n237 NAND2_X1
X205 _abc_1393_new_n40 _abc_1393_new_n238 _abc_1393_new_n42 _abc_1393_new_n199 _abc_1393_new_n236 _abc_1393_new_n96 OAI221_X1
X206 b.2 _abc_1393_new_n166 _abc_1393_new_n239 NAND2_X1
X207 _abc_1393_new_n89 _abc_1393_new_n240 _abc_1393_new_n238 _abc_1393_new_n239 AOI21_X1
X208 _abc_1393_new_n235 _abc_1393_new_n240 _abc_1393_new_n241 _abc_1393_new_n55 _abc_1393_new_n105 AOI211_X1
X209 _abc_1393_new_n237 _abc_1393_new_n241 _abc_1393_new_n242 NAND2_X1
X210 _abc_1393_new_n230 _abc_1393_new_n242 _abc_1393_new_n243 _abc_1393_new_n233 _abc_1393_new_n232 AOI211_X1
X211 _abc_1393_new_n49 _abc_1393_auto_rtlil.cc:2985:MuxGate_1374 _abc_1393_new_n243 rst_n AOI21_X1
X212 _abc_1393_new_n228 _abc_1393_new_n245 b.6 _abc_1393_new_n34 OAI21_X1
X213 _abc_1393_new_n59 _abc_1393_new_n245 _abc_1393_new_n246 XOR2_X1
X214 _abc_1393_new_n54 _abc_1393_new_n231 _abc_1393_new_n247 OR2_X1
X215 _abc_1393_new_n59 _abc_1393_new_n247 _abc_1393_new_n248 XNOR2_X1
X216 b.1 _abc_1393_new_n249 b.0 a.6 AOI21_X1
X217 b.2 _abc_1393_new_n250 b.1 _abc_1393_new_n217 _abc_1393_new_n249 _abc_1393_new_n129 AOI221_X1
X218 _abc_1393_new_n250 _abc_1393_new_n251 _abc_1393_new_n182 b.2 AOI21_X1
X219 opcode.0 _abc_1393_new_n252 b.7 a.7 OAI21_X1
X220 _abc_1393_new_n101 _abc_1393_new_n253 _abc_1393_new_n252 _abc_1393_new_n57 AOI21_X1
X221 _abc_1393_new_n253 _abc_1393_new_n254 _abc_1393_new_n186 _abc_1393_new_n92 AOI21_X1
X222 _abc_1393_new_n254 _abc_1393_new_n255 _abc_1393_new_n251 _abc_1393_new_n89 OAI21_X1
X223 _abc_1393_new_n255 _abc_1393_new_n256 _abc_1393_new_n105 _abc_1393_new_n59 AOI21_X1
X224 _abc_1393_new_n256 _abc_1393_new_n257 _abc_1393_new_n248 _abc_1393_new_n146 _abc_1393_new_n144 _abc_1393_new_n246 OAI221_X1
X225 _abc_1393_auto_hilomap.cc:47:hilomap_worker_1391 _abc_1393_new_n257 rst_n _abc_1393_auto_rtlil.cc:2985:MuxGate_1376 MUX2_X1
X226 _abc_1393_new_n114 _abc_1393_new_n150 _abc_1393_new_n259 _abc_1393_new_n171 _abc_1393_new_n191 AND4_X1
X227 _abc_1393_new_n207 _abc_1393_new_n225 _abc_1393_new_n260 _abc_1393_new_n243 _abc_1393_new_n259 NAND4_X1
X228 _abc_1393_new_n115 _abc_1393_auto_rtlil.cc:2985:MuxGate_1378 _abc_1393_new_n257 _abc_1393_new_n260 OAI21_X1
X229 _abc_1393_new_n58 _abc_1393_new_n262 _abc_1393_new_n59 _abc_1393_new_n247 AOI21_X1
X230 _abc_1393_new_n48 _abc_1393_new_n263 _abc_1393_new_n123 _abc_1393_new_n143 AOI21_X1
X231 _abc_1393_new_n263 _abc_1393_new_n264 _abc_1393_new_n262 _abc_1393_new_n146 OAI21_X1
X232 _abc_1393_new_n50 _abc_1393_new_n264 _abc_1393_auto_rtlil.cc:2985:MuxGate_1380 AND2_X1
X233 _abc_1393_auto_rtlil.cc:2985:MuxGate_1362 result.0 clk _auto_dfflibmap.cc:513:dfflibmap_1390 DFF_X1
X234 _abc_1393_auto_rtlil.cc:2985:MuxGate_1364 result.1 clk _auto_dfflibmap.cc:513:dfflibmap_1389 DFF_X1
X235 _abc_1393_auto_rtlil.cc:2985:MuxGate_1366 result.2 clk _auto_dfflibmap.cc:513:dfflibmap_1388 DFF_X1
X236 _abc_1393_auto_rtlil.cc:2985:MuxGate_1368 result.3 clk _auto_dfflibmap.cc:513:dfflibmap_1387 DFF_X1
X237 _abc_1393_auto_rtlil.cc:2985:MuxGate_1370 result.4 clk _auto_dfflibmap.cc:513:dfflibmap_1386 DFF_X1
X238 _abc_1393_auto_rtlil.cc:2985:MuxGate_1372 result.5 clk _auto_dfflibmap.cc:513:dfflibmap_1385 DFF_X1
X239 _abc_1393_auto_rtlil.cc:2985:MuxGate_1374 result.6 clk _auto_dfflibmap.cc:513:dfflibmap_1384 DFF_X1
X240 _abc_1393_auto_rtlil.cc:2985:MuxGate_1376 result.7 clk _auto_dfflibmap.cc:513:dfflibmap_1383 DFF_X1
X241 _abc_1393_auto_rtlil.cc:2985:MuxGate_1378 zero_flag clk _auto_dfflibmap.cc:513:dfflibmap_1382 DFF_X1
X242 _abc_1393_auto_rtlil.cc:2985:MuxGate_1380 overflow_flag clk _auto_dfflibmap.cc:513:dfflibmap_1381 DFF_X1
X243 _abc_1393_auto_hilomap.cc:47:hilomap_worker_1391 LOGIC0_X1

************************
* end of SPICE netlist *
************************
