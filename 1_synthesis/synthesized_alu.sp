* SPICE netlist generated by Yosys 0.50 (git sha1 b5170e139, clang++ 18.1.3 -fPIC -O3)

X0 a.1 _abc_1264_new_n33 INV_X1
X1 b.0 _abc_1264_new_n34 INV_X1
X2 a.3 _abc_1264_new_n35 INV_X1
X3 b.1 _abc_1264_new_n36 INV_X1
X4 a.5 _abc_1264_new_n37 INV_X1
X5 a.6 _abc_1264_new_n38 INV_X1
X6 b.2 _abc_1264_new_n39 INV_X1
X7 a.0 _abc_1264_new_n40 INV_X1
X8 b.4 _abc_1264_new_n41 INV_X1
X9 b.5 _abc_1264_new_n42 INV_X1
X10 b.7 _abc_1264_new_n43 INV_X1
X11 opcode.0 _abc_1264_new_n44 INV_X1
X12 opcode.3 _abc_1264_new_n45 INV_X1
X13 _abc_1264_auto_hilomap.cc:47:hilomap_worker_1262 _abc_1264_new_n46 INV_X1
X14 _abc_1264_auto_hilomap.cc:47:hilomap_worker_1262 rst_n _abc_1264_new_n47 NOR2_X1
X15 _abc_1264_new_n47 _abc_1264_new_n48 INV_X1
X16 a.7 _abc_1264_new_n43 _abc_1264_new_n49 NAND2_X1
X17 a.7 b.7 _abc_1264_new_n50 NAND2_X1
X18 a.7 b.7 _abc_1264_new_n51 XOR2_X1
X19 a.7 b.7 _abc_1264_new_n52 XNOR2_X1
X20 _abc_1264_new_n38 b.6 _abc_1264_new_n53 NOR2_X1
X21 a.6 b.6 _abc_1264_new_n54 OR2_X1
X22 a.6 b.6 _abc_1264_new_n55 NAND2_X1
X23 _abc_1264_new_n54 _abc_1264_new_n55 _abc_1264_new_n56 AND2_X1
X24 _abc_1264_new_n54 _abc_1264_new_n55 _abc_1264_new_n57 NAND2_X1
X25 _abc_1264_new_n35 b.3 _abc_1264_new_n58 NOR2_X1
X26 a.3 b.3 _abc_1264_new_n59 AND2_X1
X27 a.3 b.3 _abc_1264_new_n60 NOR2_X1
X28 _abc_1264_new_n60 _abc_1264_new_n61 INV_X1
X29 _abc_1264_new_n59 _abc_1264_new_n60 _abc_1264_new_n62 NOR2_X1
X30 a.2 _abc_1264_new_n39 _abc_1264_new_n63 NAND2_X1
X31 a.2 b.2 _abc_1264_new_n64 OR2_X1
X32 a.2 b.2 _abc_1264_new_n65 NAND2_X1
X33 _abc_1264_new_n64 _abc_1264_new_n65 _abc_1264_new_n66 AND2_X1
X34 _abc_1264_new_n64 _abc_1264_new_n65 _abc_1264_new_n67 NAND2_X1
X35 a.1 b.1 _abc_1264_new_n68 AND2_X1
X36 a.1 b.1 _abc_1264_new_n69 XOR2_X1
X37 _abc_1264_new_n69 _abc_1264_new_n70 _abc_1264_new_n40 b.0 AOI21_X1
X38 _abc_1264_new_n33 b.1 _abc_1264_new_n71 NOR2_X1
X39 _abc_1264_new_n67 _abc_1264_new_n72 _abc_1264_new_n70 _abc_1264_new_n71 OAI21_X1
X40 _abc_1264_new_n62 _abc_1264_new_n73 _abc_1264_new_n63 _abc_1264_new_n72 AOI21_X1
X41 _abc_1264_new_n58 _abc_1264_new_n73 _abc_1264_new_n74 NOR2_X1
X42 _abc_1264_new_n37 _abc_1264_new_n42 _abc_1264_new_n75 NOR2_X1
X43 a.5 b.5 _abc_1264_new_n76 XOR2_X1
X44 a.5 b.5 _abc_1264_new_n77 XNOR2_X1
X45 a.4 b.4 _abc_1264_new_n78 NAND2_X1
X46 a.4 b.4 _abc_1264_new_n79 XOR2_X1
X47 a.4 b.4 _abc_1264_new_n80 XNOR2_X1
X48 _abc_1264_new_n77 _abc_1264_new_n80 _abc_1264_new_n81 NAND2_X1
X49 _abc_1264_new_n77 _abc_1264_new_n80 _abc_1264_new_n82 _abc_1264_new_n58 _abc_1264_new_n73 OAI211_X1
X50 a.4 _abc_1264_new_n41 _abc_1264_new_n83 NAND2_X1
X51 _abc_1264_new_n76 _abc_1264_new_n83 _abc_1264_new_n84 NOR2_X1
X52 _abc_1264_new_n84 _abc_1264_new_n85 _abc_1264_new_n42 a.5 AOI21_X1
X53 _abc_1264_new_n56 _abc_1264_new_n86 _abc_1264_new_n82 _abc_1264_new_n85 AOI21_X1
X54 _abc_1264_new_n53 _abc_1264_new_n86 _abc_1264_new_n87 NOR2_X1
X55 _abc_1264_new_n52 _abc_1264_new_n88 _abc_1264_new_n53 _abc_1264_new_n86 OAI21_X1
X56 _abc_1264_new_n49 _abc_1264_new_n88 _abc_1264_new_n89 AND2_X1
X57 _abc_1264_new_n49 _abc_1264_new_n88 _abc_1264_new_n90 NAND2_X1
X58 _abc_1264_new_n45 opcode.2 _abc_1264_new_n91 NAND2_X1
X59 opcode.0 opcode.1 _abc_1264_new_n92 NAND2_X1
X60 _abc_1264_new_n91 _abc_1264_new_n92 _abc_1264_new_n93 NOR2_X1
X61 b.0 _abc_1264_new_n40 _abc_1264_new_n94 NOR2_X1
X62 b.0 a.0 _abc_1264_new_n95 AND2_X1
X63 b.0 a.0 _abc_1264_new_n96 NAND2_X1
X64 _abc_1264_new_n34 _abc_1264_new_n40 _abc_1264_new_n97 NAND2_X1
X65 _abc_1264_new_n62 _abc_1264_new_n94 _abc_1264_new_n98 NOR2_X1
X66 _abc_1264_new_n51 _abc_1264_new_n56 _abc_1264_new_n99 _abc_1264_new_n66 NOR3_X1
X67 _abc_1264_new_n70 _abc_1264_new_n98 _abc_1264_new_n100 _abc_1264_new_n99 NAND3_X1
X68 _abc_1264_new_n93 _abc_1264_new_n101 _abc_1264_new_n100 _abc_1264_new_n81 OAI21_X1
X69 _abc_1264_new_n101 _abc_1264_new_n102 INV_X1
X70 opcode.3 opcode.2 _abc_1264_new_n103 OR2_X1
X71 opcode.1 _abc_1264_new_n103 _abc_1264_new_n104 NOR2_X1
X72 opcode.1 _abc_1264_new_n91 _abc_1264_new_n105 NOR2_X1
X73 opcode.0 opcode.1 _abc_1264_new_n106 _abc_1264_new_n91 NOR3_X1
X74 _abc_1264_new_n96 _abc_1264_new_n97 _abc_1264_new_n107 _abc_1264_new_n104 _abc_1264_new_n106 OAI211_X1
X75 _abc_1264_new_n92 _abc_1264_new_n103 _abc_1264_new_n108 NOR2_X1
X76 _abc_1264_new_n97 _abc_1264_new_n108 _abc_1264_new_n109 NAND2_X1
X77 _abc_1264_new_n44 opcode.1 _abc_1264_new_n110 NAND2_X1
X78 _abc_1264_new_n103 _abc_1264_new_n110 _abc_1264_new_n111 OR2_X1
X79 _abc_1264_new_n111 _abc_1264_new_n112 INV_X1
X80 _abc_1264_new_n107 _abc_1264_new_n109 _abc_1264_new_n113 _abc_1264_new_n111 _abc_1264_new_n96 OAI211_X1
X81 b.1 _abc_1264_new_n94 _abc_1264_new_n114 a.1 b.0 AOI211_X1
X82 a.2 _abc_1264_new_n34 _abc_1264_new_n115 AND2_X1
X83 _abc_1264_new_n34 _abc_1264_new_n35 _abc_1264_new_n116 NOR2_X1
X84 _abc_1264_new_n115 _abc_1264_new_n116 _abc_1264_new_n117 NOR2_X1
X85 b.2 _abc_1264_new_n91 _abc_1264_new_n118 _abc_1264_new_n110 NOR3_X1
X86 b.2 _abc_1264_new_n91 _abc_1264_new_n119 _abc_1264_new_n110 OR3_X1
X87 _abc_1264_new_n114 _abc_1264_new_n119 _abc_1264_new_n120 _abc_1264_new_n117 b.1 AOI211_X1
X88 _abc_1264_new_n39 _abc_1264_new_n91 _abc_1264_new_n121 _abc_1264_new_n110 NOR3_X1
X89 _abc_1264_new_n39 _abc_1264_new_n91 _abc_1264_new_n122 _abc_1264_new_n110 OR3_X1
X90 a.4 a.5 b.0 _abc_1264_new_n123 MUX2_X1
X91 b.0 _abc_1264_new_n38 _abc_1264_new_n124 NOR2_X1
X92 _abc_1264_new_n124 _abc_1264_new_n125 a.7 b.0 AOI21_X1
X93 b.1 _abc_1264_new_n123 _abc_1264_new_n126 NOR2_X1
X94 _abc_1264_new_n122 _abc_1264_new_n126 _abc_1264_new_n127 _abc_1264_new_n125 b.1 AOI211_X1
X95 b.0 b.1 _abc_1264_new_n128 _abc_1264_new_n40 NOR3_X1
X96 opcode.0 _abc_1264_new_n105 _abc_1264_new_n129 NAND2_X1
X97 b.2 _abc_1264_new_n129 _abc_1264_new_n130 NOR2_X1
X98 _abc_1264_new_n39 opcode.0 _abc_1264_new_n131 _abc_1264_new_n105 NAND3_X1
X99 _abc_1264_new_n128 _abc_1264_new_n130 _abc_1264_new_n132 AND2_X1
X100 _abc_1264_new_n120 _abc_1264_new_n127 _abc_1264_new_n133 _abc_1264_new_n132 OR3_X1
X101 _abc_1264_new_n113 _abc_1264_new_n133 _abc_1264_new_n134 _abc_1264_new_n90 _abc_1264_new_n102 AOI211_X1
X102 _abc_1264_new_n47 _abc_1264_auto_rtlil.cc:2985:MuxGate_1233 _abc_1264_new_n134 rst_n AOI21_X1
X103 _abc_1264_new_n92 _abc_1264_new_n103 _abc_1264_new_n136 _abc_1264_new_n33 _abc_1264_new_n36 AOI211_X1
X104 _abc_1264_new_n136 _abc_1264_new_n137 _abc_1264_new_n106 _abc_1264_new_n69 _abc_1264_new_n68 _abc_1264_new_n112 AOI221_X1
X105 b.0 _abc_1264_new_n37 _abc_1264_new_n138 NOR2_X1
X106 _abc_1264_new_n138 _abc_1264_new_n139 a.6 b.0 AOI21_X1
X107 _abc_1264_new_n34 a.7 _abc_1264_new_n140 NAND2_X1
X108 _abc_1264_new_n34 b.1 _abc_1264_new_n141 a.7 NAND3_X1
X109 _abc_1264_new_n141 _abc_1264_new_n142 _abc_1264_new_n139 b.1 OAI21_X1
X110 opcode.0 _abc_1264_new_n104 _abc_1264_new_n143 NAND2_X1
X111 b.0 _abc_1264_new_n40 _abc_1264_new_n144 _abc_1264_new_n69 NAND3_X1
X112 _abc_1264_new_n70 _abc_1264_new_n143 _abc_1264_new_n145 NOR2_X1
X113 opcode.0 opcode.1 _abc_1264_new_n146 _abc_1264_new_n103 NOR3_X1
X114 _abc_1264_new_n44 _abc_1264_new_n104 _abc_1264_new_n147 NAND2_X1
X115 _abc_1264_new_n69 _abc_1264_new_n96 _abc_1264_new_n148 XNOR2_X1
X116 _abc_1264_new_n33 b.0 _abc_1264_new_n149 NOR2_X1
X117 _abc_1264_new_n95 _abc_1264_new_n149 _abc_1264_new_n150 NOR2_X1
X118 b.1 _abc_1264_new_n131 _abc_1264_new_n151 _abc_1264_new_n150 NOR3_X1
X119 _abc_1264_new_n149 _abc_1264_new_n152 b.0 a.2 AOI21_X1
X120 a.3 a.4 b.0 _abc_1264_new_n153 MUX2_X1
X121 _abc_1264_new_n118 _abc_1264_new_n154 _abc_1264_new_n153 _abc_1264_new_n36 OAI21_X1
X122 _abc_1264_new_n154 _abc_1264_new_n155 _abc_1264_new_n152 _abc_1264_new_n36 AOI21_X1
X123 _abc_1264_new_n151 _abc_1264_new_n156 _abc_1264_new_n142 _abc_1264_new_n121 AOI21_X1
X124 _abc_1264_new_n155 _abc_1264_new_n157 _abc_1264_new_n148 _abc_1264_new_n146 _abc_1264_new_n144 _abc_1264_new_n145 AOI221_X1
X125 _abc_1264_new_n137 _abc_1264_new_n156 _abc_1264_new_n158 _abc_1264_new_n157 NAND3_X1
X126 _abc_1264_new_n158 _abc_1264_new_n159 _abc_1264_new_n93 _abc_1264_new_n89 AOI21_X1
X127 _abc_1264_new_n47 _abc_1264_auto_rtlil.cc:2985:MuxGate_1235 _abc_1264_new_n159 rst_n AOI21_X1
X128 _abc_1264_new_n67 _abc_1264_new_n70 _abc_1264_new_n161 _abc_1264_new_n71 OR3_X1
X129 opcode.0 _abc_1264_new_n72 _abc_1264_new_n162 _abc_1264_new_n104 _abc_1264_new_n161 NAND4_X1
X130 _abc_1264_new_n68 _abc_1264_new_n163 _abc_1264_new_n69 _abc_1264_new_n95 AOI21_X1
X131 _abc_1264_new_n44 _abc_1264_new_n104 _abc_1264_new_n164 _abc_1264_new_n163 _abc_1264_new_n67 OAI211_X1
X132 _abc_1264_new_n164 _abc_1264_new_n165 _abc_1264_new_n163 _abc_1264_new_n67 AOI21_X1
X133 b.1 _abc_1264_new_n122 _abc_1264_new_n166 _abc_1264_new_n125 OR3_X1
X134 _abc_1264_new_n115 _abc_1264_new_n167 b.0 a.1 AOI21_X1
X135 b.1 _abc_1264_new_n94 _abc_1264_new_n168 NAND2_X1
X136 _abc_1264_new_n168 _abc_1264_new_n169 _abc_1264_new_n167 b.1 OAI21_X1
X137 b.1 _abc_1264_new_n123 _abc_1264_new_n170 NAND2_X1
X138 _abc_1264_new_n170 _abc_1264_new_n171 _abc_1264_new_n117 b.1 OAI21_X1
X139 _abc_1264_new_n165 _abc_1264_new_n172 _abc_1264_new_n169 _abc_1264_new_n130 _abc_1264_new_n108 _abc_1264_new_n64 AOI221_X1
X140 rst_n _abc_1264_new_n166 _abc_1264_new_n173 _abc_1264_new_n111 _abc_1264_new_n65 OAI211_X1
X141 _abc_1264_new_n173 _abc_1264_new_n174 _abc_1264_new_n171 _abc_1264_new_n118 _abc_1264_new_n66 _abc_1264_new_n106 AOI221_X1
X142 _abc_1264_new_n162 _abc_1264_new_n172 _abc_1264_new_n175 _abc_1264_new_n174 NAND3_X1
X143 _abc_1264_new_n48 _abc_1264_new_n175 _abc_1264_auto_rtlil.cc:2985:MuxGate_1237 AND2_X1
X144 _abc_1264_new_n65 _abc_1264_new_n177 _abc_1264_new_n67 _abc_1264_new_n163 OAI21_X1
X145 _abc_1264_new_n62 _abc_1264_new_n177 _abc_1264_new_n178 XNOR2_X1
X146 _abc_1264_new_n147 _abc_1264_new_n178 _abc_1264_new_n179 NOR2_X1
X147 _abc_1264_new_n62 _abc_1264_new_n63 _abc_1264_new_n180 _abc_1264_new_n72 AND3_X1
X148 _abc_1264_new_n73 _abc_1264_new_n143 _abc_1264_new_n181 _abc_1264_new_n180 NOR3_X1
X149 b.1 _abc_1264_new_n122 _abc_1264_new_n182 _abc_1264_new_n140 NOR3_X1
X150 a.3 a.2 b.0 _abc_1264_new_n183 MUX2_X1
X151 _abc_1264_new_n36 _abc_1264_new_n183 _abc_1264_new_n184 NAND2_X1
X152 _abc_1264_new_n184 _abc_1264_new_n185 _abc_1264_new_n150 _abc_1264_new_n36 OAI21_X1
X153 _abc_1264_new_n119 _abc_1264_new_n186 _abc_1264_new_n139 b.1 AOI21_X1
X154 _abc_1264_new_n186 _abc_1264_new_n187 _abc_1264_new_n153 b.1 OAI21_X1
X155 _abc_1264_new_n182 _abc_1264_new_n188 _abc_1264_new_n185 _abc_1264_new_n130 _abc_1264_new_n112 _abc_1264_new_n59 AOI221_X1
X156 _abc_1264_new_n62 _abc_1264_new_n106 _abc_1264_new_n189 _abc_1264_new_n108 _abc_1264_new_n61 AOI22_X1
X157 _abc_1264_new_n187 _abc_1264_new_n188 _abc_1264_new_n190 _abc_1264_new_n189 NAND3_X1
X158 _abc_1264_new_n179 _abc_1264_new_n181 _abc_1264_new_n191 _abc_1264_new_n190 OR3_X1
X159 _abc_1264_auto_hilomap.cc:47:hilomap_worker_1262 _abc_1264_new_n191 rst_n _abc_1264_auto_rtlil.cc:2985:MuxGate_1239 MUX2_X1
X160 _abc_1264_new_n74 _abc_1264_new_n79 _abc_1264_new_n193 NOR2_X1
X161 _abc_1264_new_n58 _abc_1264_new_n73 _abc_1264_new_n194 _abc_1264_new_n80 NOR3_X1
X162 _abc_1264_new_n143 _abc_1264_new_n193 _abc_1264_new_n195 _abc_1264_new_n194 OR3_X1
X163 _abc_1264_new_n59 _abc_1264_new_n196 _abc_1264_new_n62 _abc_1264_new_n177 AOI21_X1
X164 _abc_1264_new_n80 _abc_1264_new_n196 _abc_1264_new_n197 XNOR2_X1
X165 _abc_1264_new_n116 _abc_1264_new_n198 a.4 _abc_1264_new_n34 AOI21_X1
X166 _abc_1264_new_n36 _abc_1264_new_n198 _abc_1264_new_n199 AND2_X1
X167 _abc_1264_new_n131 _abc_1264_new_n199 _abc_1264_new_n200 _abc_1264_new_n167 b.1 AOI211_X1
X168 _abc_1264_new_n108 _abc_1264_new_n201 b.4 a.4 OAI21_X1
X169 _abc_1264_new_n201 _abc_1264_new_n202 _abc_1264_new_n111 _abc_1264_new_n78 OAI21_X1
X170 _abc_1264_new_n200 _abc_1264_new_n202 _abc_1264_new_n203 _abc_1264_new_n79 _abc_1264_new_n106 AOI211_X1
X171 _abc_1264_new_n119 _abc_1264_new_n126 _abc_1264_new_n204 _abc_1264_new_n125 b.1 AOI211_X1
X172 _abc_1264_new_n39 _abc_1264_new_n129 _abc_1264_new_n205 NOR2_X1
X173 _abc_1264_new_n204 _abc_1264_new_n206 _abc_1264_new_n205 _abc_1264_new_n128 AOI21_X1
X174 _abc_1264_new_n203 _abc_1264_new_n206 _abc_1264_new_n207 AND2_X1
X175 _abc_1264_new_n195 _abc_1264_new_n207 _abc_1264_new_n208 _abc_1264_new_n197 _abc_1264_new_n147 OAI211_X1
X176 _abc_1264_auto_hilomap.cc:47:hilomap_worker_1262 _abc_1264_new_n208 rst_n _abc_1264_auto_rtlil.cc:2985:MuxGate_1241 MUX2_X1
X177 _abc_1264_new_n78 _abc_1264_new_n210 _abc_1264_new_n80 _abc_1264_new_n196 OAI21_X1
X178 _abc_1264_new_n76 _abc_1264_new_n210 _abc_1264_new_n211 XNOR2_X1
X179 _abc_1264_new_n76 _abc_1264_new_n83 _abc_1264_new_n212 NAND2_X1
X180 _abc_1264_new_n84 _abc_1264_new_n143 _abc_1264_new_n213 NOR2_X1
X181 _abc_1264_new_n82 _abc_1264_new_n213 _abc_1264_new_n214 _abc_1264_new_n212 _abc_1264_new_n193 OAI211_X1
X182 _abc_1264_new_n92 _abc_1264_new_n103 _abc_1264_new_n215 _abc_1264_new_n37 _abc_1264_new_n42 AOI211_X1
X183 _abc_1264_new_n215 _abc_1264_new_n216 _abc_1264_new_n106 _abc_1264_new_n76 _abc_1264_new_n75 _abc_1264_new_n112 AOI221_X1
X184 b.1 _abc_1264_new_n39 _abc_1264_new_n217 _abc_1264_new_n129 _abc_1264_new_n150 OR4_X1
X185 _abc_1264_new_n216 _abc_1264_new_n217 _abc_1264_new_n218 NAND2_X1
X186 _abc_1264_new_n138 _abc_1264_new_n219 a.4 b.0 AOI21_X1
X187 _abc_1264_new_n36 _abc_1264_new_n183 _abc_1264_new_n220 NOR2_X1
X188 _abc_1264_new_n131 _abc_1264_new_n220 _abc_1264_new_n221 _abc_1264_new_n219 _abc_1264_new_n36 AOI211_X1
X189 _abc_1264_new_n218 _abc_1264_new_n221 _abc_1264_new_n222 _abc_1264_new_n118 _abc_1264_new_n142 AOI211_X1
X190 _abc_1264_new_n214 _abc_1264_new_n222 _abc_1264_new_n223 _abc_1264_new_n147 _abc_1264_new_n211 OAI211_X1
X191 _abc_1264_new_n223 _abc_1264_new_n224 INV_X1
X192 _abc_1264_new_n47 _abc_1264_auto_rtlil.cc:2985:MuxGate_1243 _abc_1264_new_n224 rst_n AOI21_X1
X193 _abc_1264_new_n75 _abc_1264_new_n226 _abc_1264_new_n76 _abc_1264_new_n210 AOI21_X1
X194 _abc_1264_new_n57 _abc_1264_new_n226 _abc_1264_new_n227 OR2_X1
X195 _abc_1264_new_n147 _abc_1264_new_n228 _abc_1264_new_n226 _abc_1264_new_n57 AOI21_X1
X196 _abc_1264_new_n56 _abc_1264_new_n82 _abc_1264_new_n229 _abc_1264_new_n85 NAND3_X1
X197 _abc_1264_new_n86 _abc_1264_new_n143 _abc_1264_new_n230 NOR2_X1
X198 b.1 _abc_1264_new_n119 _abc_1264_new_n231 _abc_1264_new_n125 NOR3_X1
X199 _abc_1264_new_n55 _abc_1264_new_n111 _abc_1264_new_n232 NOR2_X1
X200 _abc_1264_new_n231 _abc_1264_new_n233 _abc_1264_new_n106 _abc_1264_new_n56 AOI21_X1
X201 a.6 a.5 b.0 _abc_1264_new_n234 MUX2_X1
X202 b.1 _abc_1264_new_n198 _abc_1264_new_n235 NAND2_X1
X203 _abc_1264_new_n130 _abc_1264_new_n235 _abc_1264_new_n236 _abc_1264_new_n234 b.1 OAI211_X1
X204 _abc_1264_new_n232 _abc_1264_new_n237 _abc_1264_new_n205 _abc_1264_new_n169 _abc_1264_new_n54 _abc_1264_new_n108 AOI221_X1
X205 _abc_1264_new_n233 _abc_1264_new_n236 _abc_1264_new_n238 _abc_1264_new_n237 NAND3_X1
X206 _abc_1264_new_n238 _abc_1264_new_n239 _abc_1264_new_n230 _abc_1264_new_n229 _abc_1264_new_n227 _abc_1264_new_n228 AOI221_X1
X207 _abc_1264_new_n47 _abc_1264_auto_rtlil.cc:2985:MuxGate_1245 _abc_1264_new_n239 rst_n AOI21_X1
X208 _abc_1264_new_n52 _abc_1264_new_n241 _abc_1264_new_n55 _abc_1264_new_n227 AOI21_X1
X209 _abc_1264_new_n52 _abc_1264_new_n55 _abc_1264_new_n242 _abc_1264_new_n227 AND3_X1
X210 _abc_1264_new_n147 _abc_1264_new_n241 _abc_1264_new_n243 OR2_X1
X211 _abc_1264_new_n51 _abc_1264_new_n87 _abc_1264_new_n244 XNOR2_X1
X212 b.1 _abc_1264_new_n140 _abc_1264_new_n245 _abc_1264_new_n131 _abc_1264_new_n119 AOI211_X1
X213 b.1 _abc_1264_new_n246 a.6 b.0 AOI21_X1
X214 _abc_1264_new_n131 _abc_1264_new_n246 _abc_1264_new_n247 _abc_1264_new_n219 b.1 AOI211_X1
X215 _abc_1264_new_n185 _abc_1264_new_n205 _abc_1264_new_n248 AND2_X1
X216 _abc_1264_new_n108 _abc_1264_new_n249 b.7 a.7 OAI21_X1
X217 _abc_1264_new_n249 _abc_1264_new_n250 _abc_1264_new_n111 _abc_1264_new_n50 OAI21_X1
X218 _abc_1264_new_n245 _abc_1264_new_n247 _abc_1264_new_n251 _abc_1264_new_n250 OR3_X1
X219 _abc_1264_new_n248 _abc_1264_new_n251 _abc_1264_new_n252 _abc_1264_new_n51 _abc_1264_new_n106 AOI211_X1
X220 _abc_1264_new_n252 _abc_1264_new_n253 _abc_1264_new_n243 _abc_1264_new_n242 _abc_1264_new_n143 _abc_1264_new_n244 OAI221_X1
X221 _abc_1264_auto_hilomap.cc:47:hilomap_worker_1262 _abc_1264_new_n253 rst_n _abc_1264_auto_rtlil.cc:2985:MuxGate_1247 MUX2_X1
X222 _abc_1264_new_n175 _abc_1264_new_n191 _abc_1264_new_n255 _abc_1264_new_n208 _abc_1264_new_n223 NOR4_X1
X223 _abc_1264_new_n134 _abc_1264_new_n159 _abc_1264_new_n256 _abc_1264_new_n239 _abc_1264_new_n255 NAND4_X1
X224 _abc_1264_new_n46 rst_n _abc_1264_auto_rtlil.cc:2985:MuxGate_1249 _abc_1264_new_n253 _abc_1264_new_n256 OAI22_X1
X225 _abc_1264_new_n241 _abc_1264_new_n258 b.7 a.7 AOI21_X1
X226 rst_n _abc_1264_new_n259 _abc_1264_new_n90 _abc_1264_new_n143 _abc_1264_new_n147 _abc_1264_new_n258 OAI221_X1
X227 _abc_1264_new_n48 _abc_1264_new_n259 _abc_1264_auto_rtlil.cc:2985:MuxGate_1251 AND2_X1
X228 _abc_1264_auto_rtlil.cc:2985:MuxGate_1233 result.0 clk _auto_dfflibmap.cc:513:dfflibmap_1261 DFF_X1
X229 _abc_1264_auto_rtlil.cc:2985:MuxGate_1235 result.1 clk _auto_dfflibmap.cc:513:dfflibmap_1260 DFF_X1
X230 _abc_1264_auto_rtlil.cc:2985:MuxGate_1237 result.2 clk _auto_dfflibmap.cc:513:dfflibmap_1259 DFF_X1
X231 _abc_1264_auto_rtlil.cc:2985:MuxGate_1239 result.3 clk _auto_dfflibmap.cc:513:dfflibmap_1258 DFF_X1
X232 _abc_1264_auto_rtlil.cc:2985:MuxGate_1241 result.4 clk _auto_dfflibmap.cc:513:dfflibmap_1257 DFF_X1
X233 _abc_1264_auto_rtlil.cc:2985:MuxGate_1243 result.5 clk _auto_dfflibmap.cc:513:dfflibmap_1256 DFF_X1
X234 _abc_1264_auto_rtlil.cc:2985:MuxGate_1245 result.6 clk _auto_dfflibmap.cc:513:dfflibmap_1255 DFF_X1
X235 _abc_1264_auto_rtlil.cc:2985:MuxGate_1247 result.7 clk _auto_dfflibmap.cc:513:dfflibmap_1254 DFF_X1
X236 _abc_1264_auto_rtlil.cc:2985:MuxGate_1249 zero_flag clk _auto_dfflibmap.cc:513:dfflibmap_1253 DFF_X1
X237 _abc_1264_auto_rtlil.cc:2985:MuxGate_1251 overflow_flag clk _auto_dfflibmap.cc:513:dfflibmap_1252 DFF_X1
X238 _abc_1264_auto_hilomap.cc:47:hilomap_worker_1262 LOGIC0_X1

************************
* end of SPICE netlist *
************************
